# Keil uVision project stm32f103ve.uvprojx, settings and files
target stm32f103ve (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103ve +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\startup;..\library\inc;..\user;..\driver\led;..\driver\systick;..\driver\usart;..\driver\i2c;..\driver\e2prom
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group doc
    ../: readme.md
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group library
    ../library/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c
  group driver
    ../driver/systick/: bsp_systick.c
    ../driver/usart/: bsp_usart.c
    ../driver/led/: bsp_led.c
    ../driver/i2c/: bsp_i2c.c
    ../driver/e2prom/: bsp_at24c256.c
  group user
    ../user/: stm32f10x_conf.h stm32f10x_main.c stm32f10x_it.c
